# Wisp's boot logo (files/wisp-bootup.bmp: 480x800, 16-bit, the panel's portrait
# orientation), named by SUPERBIRD_BOOT_LOGO_NAME in conf/distro/wisp.conf
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
